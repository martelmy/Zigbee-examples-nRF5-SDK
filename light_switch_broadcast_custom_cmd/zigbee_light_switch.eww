<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10100\blank\iar\zigbee_light_switch_pca10100.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\zigbee_light_switch_pca10056.ewp</path>
  </project>  <batchBuild/>
</workspace>